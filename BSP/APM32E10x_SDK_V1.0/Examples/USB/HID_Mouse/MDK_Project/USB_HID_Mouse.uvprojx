# Keil uVision project USB_HID_Mouse.uvprojx, settings and files
target APM32E103_MINI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: APM32E103ZE Geehy
  pack: Geehy.APM32E1xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USB_HID_Mouse
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: APM32E10X_HD,APM32E103_MINI
  c include: ..\inc;..\..\..\..\Board;..\..\..\..\Library\APM32E10x_StdPeriphDriver\inc;..\..\..\..\Library\CMSIS\Include;..\src\usbCore;..\..\..\..\Library\Device\Geehy\APM32E10x\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../src/: apm32e10x_it.c HidMouse.c HidMouse_descriptor.c main.c
  group CMSIS
    ../../../../Library/Device/Geehy/APM32E10x/Source/: system_apm32e10x.c
    ../../../../Library/Device/Geehy/APM32E10x/Source/ARM/: startup_apm32e10x_hd.s
  group StdPeriphDriver
    ../../../../Library/APM32E10x_StdPeriphDriver/src/: apm32e10x_adc.c apm32e10x_bakpr.c apm32e10x_can.c apm32e10x_crc.c apm32e10x_dac.c apm32e10x_dbgmcu.c apm32e10x_dma.c apm32e10x_dmc.c apm32e10x_eint.c apm32e10x_emmc.c apm32e10x_fmc.c apm32e10x_gpio.c apm32e10x_i2c.c apm32e10x_iwdt.c apm32e10x_misc.c apm32e10x_pmu.c apm32e10x_rcm.c apm32e10x_rtc.c apm32e10x_sci2c.c apm32e10x_sdio.c apm32e10x_spi.c apm32e10x_tmr.c apm32e10x_usart.c apm32e10x_usb.c apm32e10x_wwdt.c
  group Board
    ../../../../Board/: Board.c
  group USBCore
    ../src/usbCore/: usb.c usb_interrupt.c usb_power.c usb_StandardRequest.c
